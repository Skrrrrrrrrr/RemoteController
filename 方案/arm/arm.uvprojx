# Keil uVision project arm.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F411CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: arm +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: C:\App\Mdk\Arm\Packs\Keil\STM32F4xx_DFP\2.16.0\CMSIS\Driver
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.cpp blink.cpp ePaper.cpp flash.cpp lcd_DevEBox.cpp UIcode.cpp Lucida_Console_27.cpp
software components: CMSIS:CORE 5.6.0, Device:STM32Cube Framework:Classic 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:STM32Cube LL:Common 1.7.13, Device:STM32Cube LL:GPIO 1.7.13, Device:STM32Cube LL:PWR 1.7.13, Device:STM32Cube LL:RCC 1.7.13, Device:STM32Cube LL:SPI 1.7.13, Device:STM32Cube LL:TIM 1.7.13, Device:STM32Cube LL:UTILS 1.7.13, Device:Startup 2.6.3
